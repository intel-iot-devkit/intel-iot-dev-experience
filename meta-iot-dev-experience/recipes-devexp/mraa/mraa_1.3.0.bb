require mraa.inc

SRC_URI = "git://github.com/intel-iot-devkit/mraa.git;protocol=git;rev=2832909856b04ee3ca792ae33d27ce00dca4da57 \
           file://ConfigurableFirmataCurieImu.ino.bin \
           file://imraa.service \
           file://imraa.conf \
          "
